Commit message: foxglove 대역폭 최적화

File: src/jupiter_description/urdf/jupiter_simple.urdf (robot description, URDF)
Before this commit: robot jupiter_simple, 7 links, 6 joints
Joints:
- joint camera_joint: origin xyz=0.274 0 0.055 rpy=0 0 0 -> xyz=0.205 0 0.098 rpy=0 0 0
